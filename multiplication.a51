MOV R0, #34H
MOV R1, #12H
MOV R2, #78H
MOV R3, #56H
MOV A, R0
MOV B, R2
MUL AB
MOV 33H, A
MOV R4, B
MOV A, R0
MOV B, R3
MUL AB
ADD A, R4
MOV R5, A
MOV A, B
ADDC A, #00H
MOV R6, A
MOV A, R1
MOV B, R2
MUL AB
ADD A, R5
MOV 32H, A
MOV A, B
ADDC A, R6
MOV 00H, C
MOV R7, A
MOV A, R3
MUL AB
ADD A, R7
MOV 31H, A
MOV A, B
MOV C, 00H
ADDC A, #00H
MOV 30H, A
END